PACKAGE_INSTALL:append:stm32mp25common = " libopenvx-gcnano libovxkernels-gcnano "
STM32MP_VENDORFS_SIZE:stm32mp25common = "147456"
